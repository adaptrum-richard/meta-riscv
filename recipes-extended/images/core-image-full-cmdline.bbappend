IMAGE_INSTALL += " \
	swupdate \
	swupdate-www \
	u-boot-fw-utils \
	mount-overlayfs \
	"